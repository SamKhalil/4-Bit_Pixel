[aimspice]
[description]
276
1-Bit Pixel circuit

.lib photodiode.cir
.include nmos_model.cir
.include pmos_model.cir

M1 N1 EXPOSE N2 Vss nm w= l=
M2 N2 ERASE  Vss Vss nm w= l=
M3 Vss N2 N3 VDD pm w= l=
M4 N3 NRE VOUT VDD pm w= l=
CS N2 Vss 1.76pf IC=0V

VDD 5V
Vss
EXPOSE
ERASE
NRE
VOUT
[end]
